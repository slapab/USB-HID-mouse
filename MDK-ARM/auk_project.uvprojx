# Keil uVision project auk_project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: auk_project
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c include: ..\Application_Inc;..\BSP_Drivers;..\BSP_STM32F429I_DISCO_LIBs;..\CMSIS\Include;..\STM32F4xx_HAL_Drivers\Inc;..\BSP_STM32F429I_DISCO_LIBs\Fonts
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application_Src/: lcd_layout.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c ts_api_extends.c
  group BSP_Drivers
    ../BSP_Drivers/: ili9341.c stmpe811.c
  group BSP_STM32F429I_DISCO_LIBs
    ../BSP_STM32F429I_DISCO_LIBs/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f429xx.s
  group STM32F4xx_HAL_Drivers
    ../STM32F4xx_HAL_Drivers/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
